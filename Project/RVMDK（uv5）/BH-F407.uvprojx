# Keil uVision project BH-F407.uvprojx, settings and files
target F4_project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\HARDWARE\led;..\..\User\sys;..\..\User\config;..\..\HARDWARE\key;..\..\HARDWARE\usart;..\..\HARDWARE\ADC;..\..\HARDWARE\PWM;..\..\HARDWARE\timer;..\..\HARDWARE\AD7606;..\..\HARDWARE\TM1638;..\..\HARDWARE\OLED;..\..\HARDWARE\ArmMath;..\..\HARDWARE\ArmMath;..\..\HARDWARE\DAC;..\..\HARDWARE\global;..\..\HARDWARE\temporary;..\..\HARDWARE\PID
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/sys/: sys.c
    ../../User/config/: config.c
  group DOC
    ../../: 必读说明.txt
  group HARDWARE
    ../../HARDWARE/led/: led.c
    ../../HARDWARE/key/: key.c
    ../../HARDWARE/usart/: usart.c
    ../../HARDWARE/PWM/: pwm.c
    ../../HARDWARE/timer/: time.c
    ../../HARDWARE/AD7606/: bsp_ad7606.c
    ../../HARDWARE/TM1638/: TM1638.c
    ../../HARDWARE/ArmMath/: arm_cortexM4lf_math.lib arm_math.h
    ../../HARDWARE/DAC/: dac.c
    ../../HARDWARE/global/: global.c
    ../../HARDWARE/temporary/: temporary.c
    ../../HARDWARE/OLED/: OLED.c OLED_Data.c
    ../../HARDWARE/PID/: pid.c
    ../../HARDWARE/SPWM/: SPWM.c SPWM.h
